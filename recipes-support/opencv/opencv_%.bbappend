EXTRA_OECMAKE:remove = "-DBUILD_opencv_dnn=OFF"
EXTRA_OECMAKE:append = " -DBUILD_opencv_dnn=ON"

