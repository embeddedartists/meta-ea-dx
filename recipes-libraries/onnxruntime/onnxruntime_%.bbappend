FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-cmake-support-NumPy-2.x-include-path.patch"

